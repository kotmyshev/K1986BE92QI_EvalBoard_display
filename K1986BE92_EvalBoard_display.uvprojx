# Keil uVision project K1986BE92_EvalBoard_display.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: K1986BE92_EvalBoard_display
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: configs.cpp conversion.cpp display_mt-128641v4.cpp main.cpp configs.h conversion.h display_mt-128641v4.h main.h
software components: CMSIS:CORE 5.3.0, Device:Startup 2.0.2i
